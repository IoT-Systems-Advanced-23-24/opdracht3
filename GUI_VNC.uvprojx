# Keil uVision project GUI_VNC.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: GUI_VNC
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EMAC_DCACHE_MAINTENANCE=0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit
  group Source Files
    ./: GUI_SingleThread.c MyDialogDLG.c GUI_VNC.c USBD_User_CDC_ACM_UART_0.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group Documentation
    ./: Abstract.txt
  group Custom Files
    ./: Temp.c Temp.h
target Release (6180000::V6.18::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: as above
  output: GUI_VNC
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EMAC_DCACHE_MAINTENANCE=0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit --diag_suppress=L6314
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, USB:CORE 6.16.1, USB:Device 6.16.1, USB:Device:CDC 6.16.1, Network:CORE 7.18.0, Network:CORE 7.18.0, Network:Interface:ETH 7.18.0, Network:Socket:BSD 7.18.0, Network:Socket:TCP 7.18.0, Network:Socket:UDP 7.18.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:LED 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:USART 1.21.0, CMSIS Driver:USB Device:High-speed 1.19.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:ETH 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PCD 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5, Graphics Display:STM32F746G-Discovery 1.0.2, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3, Graphics:Tools:GUI Builder 6.32.3, Graphics:VNC Server 6.32.3
